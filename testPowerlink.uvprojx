# Keil uVision project testPowerlink.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: testPowerlink +hex
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=4
  c define: STM32F10X_HD,_STM32
  c include: .\w5500;..\powerlink-stm32;.\powerlink\stack\src;.\powerlink\stack\include;.\powerlink\stack\src\liboplkcn;.\powerlink\contrib;.\app;.\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c LED.c stdout_USART.c
  group W5500
    ./w5500/: socket.c utility.c w5500.c w5500_conf.c types.h utility.h w5500.h w5500_conf.h socket.h
  group powerlink
    ./powerlink/stack/src/common/ami/: ami.c
    ./powerlink/stack/src/common/bufalloc/: bufalloc.c
    ./powerlink/stack/src/common/circbuf/: circbuffer.c
    ./powerlink/stack/src/common/dll/: dllcal-direct.c
    ./powerlink/stack/src/common/memmap/: memmap-null.c
    ./powerlink/stack/src/common/: debugstr.c
    ./powerlink/stack/src/kernel/ctrl/: ctrlk.c ctrlkcal-direct.c
    ./powerlink/stack/src/kernel/dll/: dllk.c dllkcal.c dllkcal-circbuf.c dllkevent.c dllkfilter.c dllkframe.c dllknode.c dllkstatemachine.c
    ./powerlink/stack/src/kernel/errhnd/: errhndk.c errhndkcal.c errhndkcal-local.c
    ./powerlink/stack/src/kernel/event/: eventk.c eventkcalintf-circbuf.c
    ./powerlink/stack/src/kernel/led/: ledk.c ledktimer.c
    ./powerlink/stack/src/kernel/nmt/: nmtk.c
    ./powerlink/stack/src/kernel/pdo/: pdok.c pdokcal.c pdokcalmem-local.c pdokcal-triplebufshm.c pdoklut.c
    ./powerlink/stack/src/kernel/timesync/: timesynck.c timesynckcal-local.c
    ./powerlink/stack/src/user/api/: generic.c processimage.c sdotest.c service.c
    ./powerlink/stack/src/user/ctrl/: ctrlu.c ctrlucal-direct.c
    ./powerlink/stack/src/user/dll/: dllucal.c dllucal-circbuf.c
    ./powerlink/stack/src/user/errhnd/: errhndu.c errhnducal-local.c
    ./powerlink/stack/src/user/event/: eventu.c eventucalintf-circbuf.c
    ./powerlink/stack/src/user/nmt/: identu.c nmtcnu.c nmtmnu.c nmtu.c statusu.c syncu.c
    ./powerlink/stack/src/user/obd/: obdal.c obdcdc.c obdconfcrc-generic.c obdconf-fileio.c obdu.c
    ./powerlink/stack/src/user/pdo/: pdou.c pdoucal.c pdoucalmem-local.c pdoucal-triplebufshm.c
    ./powerlink/stack/src/user/sdo/: sdoasnd.c sdocom.c sdocomclt.c sdocom-dummy.c sdocomsrv.c sdocom-std.c sdoseq.c sdotest-com.c sdotest-seq.c
    ./powerlink/stack/src/user/timesync/: timesyncu.c timesyncucal-local.c
    ./powerlink/stack/src/user/: cfmu.c
    ./powerlink/contrib/trace/: trace-printf.c
  group app
    ./app/: app.c app.h event.c
  group common
    ./common/eventlog/: eventlog.c eventlogstring.c
    ./common/obdcreate/: obdcreate.c
    ./powerlink/contrib/getopt/: getopt.c
    ./powerlink/contrib/console/: console-stm32.c printlog.c
  group port
    ./powerlink/stack/src/arch/stm32/: netif-stm32.c target-stm32.c target-mutex.c
    ./powerlink/stack/src/kernel/edrv/: edrv-rawsock_stm32.c
    ./powerlink/stack/src/kernel/event/: eventkcal-stm32.c
    ./powerlink/stack/src/kernel/timer/: hrestimer-stm32.c
    ./powerlink/stack/src/common/circbuf/: circbuf-stm32.c
    ./powerlink/stack/src/user/event/: eventucal-stm32.c
    ./powerlink/stack/src/user/timer/: timer-stm32user.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:SPI 2.18, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
